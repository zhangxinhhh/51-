# Keil uVision project ADC_DAC_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: ADC_DAC_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Project_1
  group Source Group 1
    ./: key.c lcd.c main.c adc.c show.c run.c
